# Keil uVision project stm32_demo.uvprojx, settings and files
target stm32_demo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,startup_stm32f10x_md
  c include: ..\FWlib\inc;..\User;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group User
    ./: main.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
